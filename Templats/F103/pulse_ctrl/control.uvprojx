# Keil uVision project control.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: control
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\Libs\inc;..\maiChong_control
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./: main.c
  group Apps
    ./: led.c time.c init.c duty.c
  group Libs
    ./Libs/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_it.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
